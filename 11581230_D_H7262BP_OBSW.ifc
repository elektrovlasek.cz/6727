Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2020-08-20T14:22:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170419_0315(x64) - Exporter 17.0.1128.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 20 14:22:51 2020 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{236B7FDE-400C-4A7E-8F74-E75AEB05AC1F}\ifc * Database version: 5507 * Database creation date: Thu Aug 20 14:22:49 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 20 14:22:50 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 20 14:22:50 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 22726225_D_11581230_H7262BP_OBSW, 11581230_D_H7262BP_OBSW:22726225_D_11581230_H7262BP_OBSW:206017
In: Level 1
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - Reference: 22726225_D_11581230_H7262BP_OBSW
Pset_ManufacturerTypeInformation - Manufacturer: Miele
